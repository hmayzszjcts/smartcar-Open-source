# IAR project VCAN_KL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z256xxx4 Freescale MKL26Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\SD_CARD
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VCAN_KL.hex
  ILINK.IlinkOutputFile: VCAN_KL.out
  ILINK.IlinkIcfFile: config files\256KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 3
  group App
    ../../Board/Src/: Fuzzy.c Motor_control.c Servo_motor_control.c
    ../../App/: main.c MKL_conf.c MKL_it.c
    ../../App/Inc/: MKL_conf.h PORT_cfg.h
  group Board
    ../../Board/Src/: 24C02.c Encoder.c Gyroscope.c Motor.c OLED.c Reed.c Senser.c Servo_motor.c Switch.c VCAN_LED.C VCAN_NRF24L0.c
  group Chip
    ../../Chip/Src/: IIC_sim.c misc.c MKL_adc.c MKL_dac.c MKL_dma.c MKL_flash.c MKL_gpio.c MKL_i2c.c MKL_lptmr.c MKL_mcg.c MKL_PIT.c MKL_port.c MKL_spi.c MKL_SysTick.c MKL_TPM.c MKL_uart.c MKL_wdog.c
    ../../Board/Src/: MKL_Scope.c
    ../../Chip/Src/IAR/: startup_MKL.s system_MKL.c vectors.c
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM0plusl_math.a

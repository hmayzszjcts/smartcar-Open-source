# IAR project KEA.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 NXP KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; TRK_KEA128; CPU_KEA128; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\App\inc; ..\Broad\inc; ..\Chip\inc; ..\Lib\inc; ..\User\inc; ..\Lib\Startup\inc; ..\Lib\Drivers\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KEA.srec
  ILINK.IlinkOutputFile: KEA.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App/inc
    ../App/inc/: bsp_global_var.h bsp_my_oled.h bsp_oled.h car_init.h common.h flash_param.h gpio_icf.h ir.h KEA128_port_cfg.h misc.h ui_debug.h ui_debug_common.h ui_setpage.h
  group App/src
    ../App/src/: bsp_global_var.c bsp_my_oled.c bsp_oled.c car_init.c common.c flash_param.c ir.c misc.c ui_debug.c ui_debug_common.c ui_setpage.c
  group Libraries/Drivers/inc
    ../Lib/Drivers/inc/: KEA128_adc.h KEA128_flash.h KEA128_ftm.h KEA128_gpio.h KEA128_irq.h KEA128_kbi.h KEA128_pit.h KEA128_port.h KEA128_systick.h KEA128_uart.h
  group Libraries/Drivers/src
    ../Lib/Drivers/src/: KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_systick.c KEA128_uart.c
  group Libraries/Startup
    ../Lib/Startup/: startup_SKEAZ1284.s
  group Libraries/Startup/inc
    ../Lib/Startup/inc/: core_cm0plus.h core_cmFunc.h core_cmInstr.h SKEAZ1284.h system_SKEAZ1284.h
  group Libraries/Startup/src
    ../Lib/Startup/src/: system_SKEAZ1284.c
  group User/inc
    ../User/inc/: Blueteeth.h direction.h includefile.h isr.h main.h scope.h speed.h
  group User/src
    ../User/src/: Blueteeth.c direction.c isr.c main.c scope.c speed.c

# IAR project fire_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\drivers\sdhc; ..\..\src\app; ..\..\src\app_image; ..\..\src\app_mydriver; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\camera; ..\..\src\drivers\dma; ..\..\src\drivers\port; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\flash; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\build; ..\..\src\uCOS-II\Ports; ..\..\src\uCOS-II\Source; ..\..\src\uCOS-II\App; ..\..\src\uCOS-II\App\CFG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group app
    ../../src/app_mydriver/: Car_init.c Car_init.h
    ../../src/app/: isr.c ISR_fun.c ISR_fun.h main.c
  group app_image
    ../../src/app_image/: define.h Process.c Process.h SmallS_Cross.c SmallS_Cross.h Startline_Ren_Block.c Startline_Ren_Block.h
    ../../src/app/: include.h
    ../../src/app_mydriver/: SD_SendDriver.c SD_SendDriver.h
  group app_mydriver
    ../../src/app_image/: About_Image.c About_Image.h
    ../../src/app_mydriver/: IIC.c IIC.h LCD.c LCD.h mytype.h
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/AT24C02/: AT24C02.c
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/dma/: dma.c dma.h
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/Flash/: flash.c flash.h
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/i2c/: i2c.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/camera/: OV7725.c OV7725.h SCCB.c SCCB.h
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/port/: port.c port.h
    ../../src/drivers/sdhc/: sdhc.c sdhc.h
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/drivers/: fire_drivers_cfg.h
    ../../src/app/: isr.h
    ../../src/platforms/: k60_fire.h
  group LIB/CMSIS
    ../../src/LIB/CMSIS/: iar_cortexM4l_math.a
  group LIB/FatFs
    ../../src/LIB/FatFs/: diskio.c ff.c
  group uCOS-II/App
    ../../src/uCOS-II/App/: app.c app_hooks.c BSP.c
  group uCOS-II/App/CFG
    ../../src/uCOS-II/App/CFG/: app_cfg.h os_cfg.h
  group uCOS-II/Ports
    ../../src/uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    ../../src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c

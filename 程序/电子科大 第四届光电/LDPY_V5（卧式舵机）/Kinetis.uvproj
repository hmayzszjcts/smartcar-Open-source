# Keil uVision project Kinetis.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: Kinetis
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: .\CMSIS;.\Library;.\Listing;.\Output;.\Startup;.\User;.\LDPY
  asm include: .\LDPY;.\Startup;.\User
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group system
    ./CMSIS/: core_cm4.c
    ./Startup/: system_MK60DZ10.c startup_MK60DZ10.s MK60DZ10.h system_MK60DZ10.h
  group LDPY
    ./LDPY/: LDPY_ADC.c LDPY_EXTI.c LDPY_GPIO.c LDPY_SysTick.c LDPY_UART.c LDPY_PIT.c LDPY_Isr.c LDPY_ASCIIConfig.c LDPY_DMA.c LDPY_Flash.c LDPY_TypeChange.h
  group User
    ./User/: myKey.c myLED.c myOLED.c myOLED_menu.c myLabVIEW.c myFlashReadWrite.c myCarControl.c myCCD.c myGyro.c mySteer.c myMotor.c myRemRoad.c myMain.c myIncludes.h myStruct.h 调试文档.txt

<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\..\Driver\function.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\function.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\main.c</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <file>
      <name>$PROJ_DIR$\..\Driver\button.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\button.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\camera.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\camera.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\control.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\control.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\eeprom.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\fuzzy.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\fuzzy.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\I2C.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\I2C.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\led.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\oled12864.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\oled12864.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\SCCB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\SCCB.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\sdcard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\sdcard.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\search.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Driver\search.h</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_DWT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_ftm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_SysTick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\MK60_wdog.c</name>
    </file>
  </group>
  <group>
    <name>system</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\inc\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\inc\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\MK60_conf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demo\app\inc\MK60_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\inc\PORT_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\IAR\startup_MK60DZ10.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\IAR\system_MK60DZ10.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Lib\Chip\src\vectors.c</name>
    </file>
  </group>
</project>



# IAR project camera.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\app; ..\app\inc; ..\..\..\Lib\Chip\inc; ..\..\..\Lib\Chip\inc\IAR; ..\..\..\Lib\Chip\inc\kinetis; ..\..\..\Lib\CMSIS\inc; ..\..\..\Lib\Board\inc; ..\Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: camera.srec
  ILINK.IlinkOutputFile: mydemo.out
  ILINK.IlinkIcfFile: ..\..\..\Lib\icf_files\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: camera.out
  group app
    ../Driver/: function.c function.h
    ../app/: main.c
  group Driver
    ../Driver/: button.c button.h camera.c camera.h control.c control.h debug.c debug.h eeprom.c eeprom.h fuzzy.c fuzzy.h I2C.c I2C.h led.c led.h oled12864.c oled12864.h SCCB.c SCCB.h sdcard.c sdcard.h search.c search.h
  group lib
    ../../../Lib/Chip/src/: MK60_adc.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c
  group system
    ../../../Lib/Chip/inc/: common.h
    ../app/inc/: include.h PORT_cfg.h
    ../../../Lib/Chip/src/: misc.c vectors.c
    ../app/: MK60_conf.c
    ../../demo/app/inc/: MK60_conf.h
    ../../../Lib/Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c

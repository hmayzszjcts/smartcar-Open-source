# IAR project SmartCar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z256xxx4 Freescale MKL26Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\Driver; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\SD_CARD
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.bin
  ILINK.IlinkOutputFile: VCAN_KL.out
  ILINK.IlinkIcfFile: config files\app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: VCAN_KL.hex
  ILINK.IlinkIcfFile: config files\256KB_Pflash.icf
  group App
    ../../App/: MKL_conf.c
    ../../Driver/: SmartCar.c
  group App/Inc
    ../../App/Inc/: include.h MKL_conf.h PORT_cfg.h
  group Chip
    ../../Chip/Src/: misc.c MKL_adc.c MKL_flash.c MKL_gpio.c MKL_lptmr.c MKL_mcg.c MKL_PIT.c MKL_port.c MKL_spi.c MKL_SysTick.c MKL_TPM.c MKL_uart.c MKL_wdog.c
    ../../Chip/Src/IAR/: startup_MKL.s system_MKL.c vectors.c
  group Driver
    ../../Driver/: CCD.c CCD.h control.c control.h debug.c debug.h eeprom.c eeprom.h fuzzy.c fuzzy.h I2C.c I2C.h init.c init.h oled.c oled.h SD_Card.c SD_Card.h Search.c Search.h
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM0plusl_math.a
